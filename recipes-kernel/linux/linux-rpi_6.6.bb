require linux-rpi.inc

LINUX_VERSION = "6.6.36"
LINUX_BRANCH = "rpi-6.6.y"
LINUX_KMETA_BRANCH ?= "yocto-6.6"

SRCREV_meta = "733366844f5e114221372929392bf237fc8d823c"
SRCREV_machine = "769634f344626ed73bcda14c91b567067974d7b2"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"